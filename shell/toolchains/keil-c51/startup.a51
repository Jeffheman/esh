; Copyright 2026 esh contributors. SPDX-License-Identifier: Apache-2.0
NAME ESH_STARTUP

?C_C51STARTUP SEGMENT CODE
?STACK SEGMENT IDATA
RSEG ?STACK
DS 1

EXTRN CODE (?C_START)
EXTRN DATA (?C_XBP)
PUBLIC ?C_STARTUP

CSEG AT 0
?C_STARTUP:
LJMP STARTUP1

RSEG ?C_C51STARTUP
STARTUP1:
MOV R0,#0FFH
CLR A
CLEAR_IDATA:
MOV @R0,A
DJNZ R0,CLEAR_IDATA

MOV DPTR,#0
MOV R6,#0F0H
MOV R7,#0
CLEAR_XDATA:
MOVX @DPTR,A
INC DPTR
DJNZ R7,CLEAR_XDATA
DJNZ R6,CLEAR_XDATA

; Keep the downward-growing reentrant stack outside BL51's XDATA allocation.
MOV ?C_XBP,#0FFH
MOV ?C_XBP+1,#0
MOV SP,#?STACK-1
LJMP ?C_START
END
