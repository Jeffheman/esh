# Keil uVision project esh-8051.uvproj, settings and files
target Simulator (MCS-51)
  device: 8XC52 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(11059200) MODP2
  output: esh-8051 +hex
  BeforeMake: python "$P..\..\..\shell\toolchains\keil-c51\build.py" --uvision-project "#P" --uvision-output "#L" --keil-root "$K."
  c flags: Optimize=8 SizeSpeed=1
  c define: ESH_UVISION_COMMANDS,ECHO_INIT_VALUE=1,__PROMPT__=esh,__BUILD_USER__=uVision,__BUILD_HOST__=uVision,__SHELL_VERSION__=unknown,__USER_REPO_VERSION__=unknown
  c include: ..\..\..\shell\shell;..\..\..\shell\lib\a2i;..\..\..\shell\lib\memlog;..\..\..\shell\lib\printf;..\..\..\shell\lib\regs;..\..\..\shell\lib\string;..\..\..\shell\lib\utils
  link misc: NOOVERLAY
  group Application
    ./: hello.c platform.c commands_uv.c
  group Shell
    ../../../shell/shell/: shell.c shell.h shell_config.h esh_port.h
  group Libraries
    ../../../shell/lib/a2i/: a2i.c
    ../../../shell/lib/memlog/: memlog.c
    ../../../shell/lib/printf/: printf.c
    ../../../shell/lib/string/: string.c
    ../../../shell/lib/utils/: utils.c
  group Startup
    ../../../shell/toolchains/keil-c51/: startup.a51
    ./: simulator.ini
